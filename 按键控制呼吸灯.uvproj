# Keil uVision project 按键控制呼吸灯.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 按键控制呼吸灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: Delay.c Delay.h LCD1602.c LCD1602.h Timer0.c Timer0.h 第二问.c
